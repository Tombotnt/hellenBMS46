# Repository Tombotnt/hellenBMS46 (continued)

## KiCad design hellenbms46.kicad_pcb (continued)

Board: 4 copper layers, 97 parts (0 on the bottom side), 140 nets, no tracks yet.

File boards/hellenbms46-a/frame/bms46-BOM.csv:

Comment,Designator,Footprint,LCSC Part #
"Battery_Cell","BT3001","BatteryHolder_Keystone_1058_1x2032",""
"10n","C6001","C0603",""
"10u","C6002","C0603",""
"10u","C6003","C0603",""
"10u","C9001","C0805",""
"10n","C9002","C0805",""
"10n","C9003","C0805",""
"10u","C10001","C0805",""
"10n","C10002","C0805",""
"10n","C10003","C0805",""
"1N4148WS","D3001","SOD-323","C2128"
"10A","F2001","36911600000","C354908"
"10A","F2002","36911600000","C354908"
"10A","F2003","36911600000","C354908"
"10A","F2004","36911600000","C354908"
"50mA","F4001","Fuse_0603_1608Metric","C369141"
"50mA","F4002","Fuse_0603_1608Metric","C369141"
"50mA","F4003","Fuse_0603_1608Metric","C369141"
"50mA","F4004","Fuse_0603_1608Metric","C369141"
"50mA","F11001","Fuse_0603_1608Metric","C369141"
"Conn_02x12_Top_Bottom","J2001","348260240",""
"Conn_02x03_Top_Bottom","J2002","Molex_Mini-Fit_Jr_5569-06A2_2x03_P4.20mm_Horizontal",""
"USB_B","J3001","USB_B","C46392"
"Jumper_2_Bridged","JP2001","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Open","JP2002","PAD-0805-PAD","C17477"
"Jumper_2_Bridged","JP2003","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Bridged","JP2004","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Bridged","JP2005","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Open","JP2006","PAD-0805-PAD","C17477"
"Jumper_2_Open","JP2007","PAD-0805-PAD","C17477"
"Jumper_2_Open","JP2008","PAD-0805-PAD","C17477"
"Jumper_2_Open","JP2009","PAD-0805-PAD","C17477"
"Jumper_2_Bridged","JP2010","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Bridged","JP2011","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Bridged","JP2012","SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm",""
"Jumper_2_Open","JP4001","PAD-0805-PAD","C17477"
"Jumper_2_Open","JP4002","PAD-0805-PAD","C17477"
"Jumper_2_Open","JP4003","PAD-0805-PAD","C17477"
"Jumper_2_Open","JP4004","PAD-0805-PAD","C17477"
"Module:power_12and5V/0.2","M3001","power_12and5V",""
"Module:mega-mcu100/0.3","M3002","mega-mcu100",""
"Module:wbo/0.5","M3003","wbo",""
"Module:can/0.1","M3004","can",""
"Module:lin/0.1","M3005","lin",""
"Module:knock/0.2","M6001","knock",""
"Module:knock/0.2","M6002","knock",""
"134pin_7-967288-1_KC5","P2001","7-967288-1_134-pin-connector",""
"ISL9V3040D3ST","Q4001","DPAK",""
"ISL9V3040D3ST","Q4002","DPAK",""
"ISL9V3040D3ST","Q4003","DPAK",""
"ISL9V3040D3ST","Q4004","DPAK",""
"ISL9V3040D3ST","Q11001","DPAK",""
"22","R4001","R0603","C23345"
"22","R4002","R0603","C23345"
"22","R4003","R0603","C23345"
"22","R4004","R0603","C23345"
"4.7k","R5001","R0603","C23162"
"4.7k","R5002","R0603","C23162"
"4.7k","R5003","R0603","C23162"
"4.7k","R5004","R0603","C23162"
"4.7k","R7001","R0603","C23162"
"4.7k","R7002","R0603","C23162"
"4.7k","R7003","R0603","C23162"
"4.7k","R7004","R0603","C23162"
"4.7k","R8001","R0603","C23162"
"4.7k","R8002","R0603","C23162"
"4.7k","R8003","R0603","C23162"
"4.7k","R8004","R0603","C23162"
"1k","R9001","R0603",""
"1k","R9002","R0603",""
"10k","R9003","R0603",""
"10k","R9004","R0603",""
"1k","R10001","R0603",""
"1k","R10002","R0603",""
"10k","R10003","R0603",""
"10k","R10004","R0603",""
"22","R11001","R0603","C23345"
"TestPoint","TP3001","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3002","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3003","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3004","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3005","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3006","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3007","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3008","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3009","TestPoint_Keystone_5000-5004_Miniature",""
"TestPoint","TP3010","TestPoint_Keystone_5000-5004_Miniature",""
"VNLD5160TR-E","U5001","SO8","C377942"
"VNLD5160TR-E","U5002","SO8","C377942"
"MCP6002-xSN","U6001","SO8",""
"VNLD5160TR-E","U7001","SO8","C377942"
"VNLD5160TR-E","U7002","SO8","C377942"
"VNLD5160TR-E","U8001","SO8","C377942"
"VNLD5160TR-E","U8002","SO8","C377942"
"TC4427xOA","U9001","SO8",""
"TC4427xOA","U10001","SO8",""
